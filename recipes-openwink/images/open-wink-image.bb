inherit open-wink-image

DESCRIPTION = "Open Wink image"

MACHINE = "qemux86"

IMAGE_INSTALL += " bash mtd-utils"
