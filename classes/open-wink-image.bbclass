inherit core-image

LICENSE = "MIT"

IMAGE_INSTALL += " base-files base-passwd busybox"
